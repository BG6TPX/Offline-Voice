# Keil uVision project STM32-LD3320(1).uvproj, settings and files
target STM32-LD3320-Driver (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-LD3320 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\M3lib\inc;..\user;..\LD_Driver
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../user/: main.c stm32f10x_it.c fyy_delay.c
  group StdPeriph_Driver
    ../M3lib/SRC/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_spi.c
  group CMSIS
    ../user/: core_cm3.c system_stm32f10x.c
  group RVMDK
    ../startup/: startup_stm32f10x_hd.s
  group LD3320 \Driver
    ../LD_Driver/: LD3320_main.c LDChip.c Reg_RW.c
  group other
    ../user/: LEDtest.C
